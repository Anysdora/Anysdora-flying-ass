# Keil uVision project STM32-DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, EMPL_TARGET_STM32F4, MPU6050
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\BSP\CONTROL;..\BSP\IIC;..\BSP\LED;..\BSP\MOTOR;..\BSP\MPU6050;..\BSP\PWM_IN;..\BSP\TIM;..\BSP\UART;..\BSP\Delay;..\BSP\ADC;..\BSP\OLED;..\BSP\PARAM;..\BSP\NRF24L01;..\BSP\SPI;..\BSP\ANO_TC;..\BSP\ULTRASONIC;..\BSP\HEIGHT;..\BSP\STMFLASH;..\BSP\POSITION;..\BSP\CAMERA;..\BSP\COMMUNICATION;..\BSP\NVIC_CONFIG;..\BSP\DISPLAY;..\BSP\INITIALIZATION;..\BSP\10-AXIS;..\BSP\GESTURE;..\BSP\MS5611;..\BSP\STATE_MACHINE;..\BSP\BUSINESS_MODE;..\BSP\KEY;..\BSP\HCI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group SYS
    ./: main.c stm32f10x_it.c
    ../BSP/COMMUNICATION/: communication.c
    ../BSP/DISPLAY/: display.c
    ../BSP/HCI/: hci.c
  group CONTROL
    ../BSP/CONTROL/: CONTROL.c
    ../BSP/GESTURE/: gesture.c
    ../BSP/HEIGHT/: height.c
    ../BSP/POSITION/: position.c
    ../BSP/PARAM/: Param.c
    ../BSP/STATE_MACHINE/: state_machine.c
    ../BSP/BUSINESS_MODE/: business_mode.c
  group DRIVE
    ../BSP/ADC/: adc.c
    ../BSP/LED/: led.c
    ../BSP/KEY/: KEY.c
    ../BSP/MOTOR/: moto.c
    ../BSP/NRF24L01/: NRF24L01.c
    ../BSP/OLED/: oled.c
    ../BSP/PWM_IN/: Tim_PWM_IN.c
    ../BSP/SPI/: Spi.c
    ../BSP/STMFLASH/: stmflash.c
    ../BSP/TIM/: time.c
    ../BSP/UART/: usart.c
    ../BSP/NVIC_CONFIG/: nvic.c
    ../BSP/Delay/: delay.c
    ../BSP/ANO_TC/: ano_tc.c
    ../BSP/INITIALIZATION/: init.c
    ../BSP/10-AXIS/: inv_mpu.c inv_mpu_dmp_motion_driver.c inv_mpu_user.c _10_axis.c
    ../BSP/IIC/: I2C.c
    ../BSP/ULTRASONIC/: ultrasonic.c
    ../BSP/CAMERA/: camera.c
